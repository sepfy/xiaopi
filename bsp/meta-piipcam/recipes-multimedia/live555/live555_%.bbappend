SUMMARY = "live555"
DESCRIPTION = "live555"
LICENSE = "CLOSED"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI +=  " \
    file://0001-Force-to-30-fps.patch \
"


